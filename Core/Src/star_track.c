#include "star_track.h"
#include "dial_font.h"
#include <string.h>
#include <math.h>

/* 第三个功能：找梅花轮并测齿频。只在 METER_MODE_STAR 下由 main.c 调用。
 * 四针读数（dial_read）和升针测速（speed_track）源码都不改。字形只放在本文件。 */

#define ST_PI        3.14159265358979f
#define ST_TWO_PI    6.28318530717959f
#define TXT_INK      0xF800U   /* 红字 */
#define TXT_VAL      0x001FU   /* 数值：蓝字 */
#define LIVE_RIM     0xFFE0U   /* 齿顶圆：黄 */
#define LIVE_ANN     0x07E0U   /* 采样圆环：绿 */
#define LIVE_MARK    0xFFFFU   /* 相位标记：白 */
#define MIN_Q        0.04f     /* N 次谐波幅度 / 平均亮度 低于此值丢帧 */
#define GAP_US       120000U   /* 相邻有效帧超过 120 ms 不再展开，重新起算 */
#define RATE_WIN_US  2000000U  /* 实时齿/s 按约 2 s 窗口 */
#define RATE_MIN_US  1000000U
/* 测量窗（梅花轮）：单圈 <30 s 累加整圈到总时长 >30 s；单圈 >=30 s 跑 1 圈（至少一整圈）。 */
#define MW_TOTAL_US  30000000U
#define LOST_US      1500000U
#define MAX_CAND     24
#define DARK_PCT     55        /* 暗阈值 = 亮度中位数 × 55% */
#ifndef STAR_T_FRAC
#define STAR_T_FRAC  45
#endif
#define CHROMA_MAX   70        /* 红针、蓝圈、红字不算暗 */
#ifndef FILL_MIN
#define FILL_MIN     30
#endif

star_info_t g_star;
volatile uint32_t g_star_isr_frames;
volatile uint32_t g_star_isr_bad;
volatile uint16_t g_star_isr_lines;
volatile uint32_t g_star_ring_drop;
double   g_star_accum;
int32_t  g_star_tps_e3;
int32_t  g_star_fps_e1;
uint32_t g_star_frame_dt_us;
uint16_t g_star_seq;
uint8_t  g_star_meas_n;
uint8_t  g_star_meas_i;
uint32_t g_star_gap_n;
uint32_t g_star_lowq_n;
uint32_t g_star_good_n;
uint32_t g_star_lost_n;          /* 1.5 s 无有效帧、回小窗重定位的次数 */
uint32_t g_star_arm_n;           /* 建表次数 */
uint16_t g_star_bad_lines;       /* 最近一次行数不对的帧的行数 */
int32_t  g_star_rep_e4;
int32_t  g_star_dir;            /* +1/-1，相位增加方向 */
float    g_star_last_q;
float    g_star_last_phase;
uint32_t g_star_last_stamp;
uint32_t g_star_meas_dt_us[STAR_MEAS_HIST];
int32_t  g_star_meas_ang_mdeg[STAR_MEAS_HIST];   /* 每次测量的总转角，m° */
int32_t  g_star_meas_dps_e3[STAR_MEAS_HIST];     /* 每次测量 °/s ×1000 */
uint8_t  g_star_meas_laps[STAR_MEAS_HIST];
double   g_star_wheel_deg;      /* 展开后的轮转角（相对起点，有符号，°） */
int32_t  g_star_ang_mdeg;       /* 白线（缺口中心参考）当前角 0~360°，m° */
int32_t  g_star_dps_e3;         /* 约 2 s 窗口的实时 °/s ×1000 */
uint32_t g_star_lap_us;         /* 最近一整圈用时 */
uint8_t  g_star_mw_laps;        /* 当前测量窗已走整圈数 */
uint8_t  g_star_mw_target;      /* 本窗需要的圈数（0 = 按总时长 >30 s） */
double   g_star_lap_deg;        /* 当前这一圈已转角度（绝对值） */
uint16_t g_star_meas_seq[STAR_MEAS_HIST];
uint16_t g_star_prof[STAR_BINS];   /* 最近一帧圆环各格平均亮度 ×16，J-Link 查看 */
uint16_t g_star_rmax[180];         /* 最近一次定位的每 2° 外缘半径（降采样像素） */

/* ---------- 行中断采样表 ---------- */
static uint32_t s_tab[STAR_TAB_MAX];
static uint16_t s_row_start[STAR_ROW_MAX + 1U];
static uint16_t s_row0;
static uint16_t s_row1;
static float    s_cosn[STAR_BINS];
static float    s_sinn[STAR_BINS];
static float    s_cinv[STAR_BINS];
static volatile uint8_t s_tab_on;
static uint8_t  s_frame_tab;
static volatile uint8_t s_gen;
static uint8_t  s_frame_gen;
static volatile uint16_t s_line;
static uint32_t s_acc[STAR_BINS];

typedef struct { uint32_t stamp; float phase; float q; } star_evt_t;
static star_evt_t s_ring[STAR_RING];
static volatile uint16_t s_ring_head;
static uint16_t s_ring_tail;

/* ---------- 主循环测量状态 ---------- */
static uint8_t  s_have_prev;
static float    s_prev_phase;
static uint32_t s_prev_stamp;
static float    s_phase0;
static uint32_t s_hist_t[STAR_HIST];
static double   s_hist_a[STAR_HIST];
static uint16_t s_hist_n;
static uint16_t s_hist_i;
static uint8_t  s_meas_on;
static uint32_t s_lap_t0;
static double   s_lap_a0;
static uint32_t s_mw_t0;
static double   s_mw_ang;
static uint32_t s_fps_t0;
static uint32_t s_fps_n;
static uint32_t s_last_good;
static uint32_t s_last_lcd_stamp;
static uint16_t s_hud_x1 = 480U;
static uint16_t s_hud_y1 = 120U;

/* ---------- 定位候选 ---------- */
typedef struct
{
  int32_t area;
  int16_t minx, maxx, miny, maxy;
} cand_t;

static float s_c360[360];
static float s_s360[360];
static uint8_t s_trig_ok;

static void trig_init(void)
{
  int k;
  if (s_trig_ok != 0U) { return; }
  for (k = 0; k < 360; k++)
  {
    float a = ((float)k) * (ST_PI / 180.0f);
    s_c360[k] = cosf(a);
    s_s360[k] = sinf(a);
  }
  s_trig_ok = 1U;
}

static void hist_reset(void)
{
  s_hist_n = 0U;
  s_hist_i = 0U;
}

static void track_reset(void)
{
  s_have_prev = 0U;
  s_prev_phase = 0.0f;
  s_prev_stamp = 0U;
  s_phase0 = 0.0f;
  g_star_accum = 0.0;
  g_star_wheel_deg = 0.0;
  g_star_dps_e3 = 0;
  g_star_lap_us = 0U;
  g_star_mw_laps = 0U;
  g_star_mw_target = 0U;
  g_star_lap_deg = 0.0;
  g_star_tps_e3 = 0;
  g_star_fps_e1 = 0;
  g_star_seq = 0U;
  g_star_meas_n = 0U;
  g_star_meas_i = 0U;
  g_star_rep_e4 = 0;
  g_star_gap_n = 0U;
  g_star_lowq_n = 0U;
  g_star_good_n = 0U;
  g_star_dir = 0;
  s_meas_on = 0U;
  s_fps_t0 = 0U;
  s_fps_n = 0U;
  s_last_good = 0U;
  hist_reset();
}

void StarTrack_Reset(void)
{
  StarTrack_Disarm();
  memset(&g_star, 0, sizeof(g_star));
  track_reset();
}

void StarTrack_HudRect(uint16_t *x1, uint16_t *y1)
{
  if (x1 != 0) { *x1 = s_hud_x1; }
  if (y1 != 0) { *y1 = s_hud_y1; }
}

/* ======================= 定位 ======================= */

static int px_luma_chroma(uint16_t p, int *chroma)
{
  int r = (int)((p >> 11) & 31U);
  int g = (int)((p >> 5) & 63U);
  int b = (int)(p & 31U);
  int mx, mn;
  r = (r << 3) | (r >> 2);
  g = (g << 2) | (g >> 4);
  b = (b << 3) | (b >> 2);
  mx = r; if (g > mx) { mx = g; } if (b > mx) { mx = b; }
  mn = r; if (g < mn) { mn = g; } if (b < mn) { mn = b; }
  *chroma = mx - mn;
  return ((r * 77) + (g * 150) + (b * 29)) >> 8;
}

/* 以 (cx,cy) 为中心每 2° 向外找候选像素最远半径（降采样像素，×1）。 */
static void cast_rays(const uint8_t *cmap, int W, int H, uint8_t id, float cx, float cy,
                      float rmax, float *rr)
{
  int k;
  for (k = 0; k < 180; k++)
  {
    float c = s_c360[k * 2];
    float s = s_s360[k * 2];
    float r;
    float best = 0.0f;
    for (r = 1.0f; r <= rmax; r += 0.5f)
    {
      int x = (int)(cx + (r * c) + 0.5f);
      int y = (int)(cy + (r * s) + 0.5f);
      if ((x < 0) || (y < 0) || (x >= W) || (y >= H)) { break; }
      if (cmap[(y * W) + x] == id) { best = r; }
    }
    rr[k] = best;
  }
}

static void sort_f(float *a, int n)
{
  int i, j;
  for (i = 1; i < n; i++)
  {
    float v = a[i];
    j = i - 1;
    while ((j >= 0) && (a[j] > v)) { a[j + 1] = a[j]; j--; }
    a[j + 1] = v;
  }
}

/* Kasa 圆拟合：x²+y²+Dx+Ey+F=0 */
static int fit_circle_f(const float *xs, const float *ys, int n, float *ocx, float *ocy, float *orad)
{
  double sx = 0, sy = 0, sxx = 0, syy = 0, sxy = 0, sz = 0, sxz = 0, syz = 0;
  double a[3][4];
  int i, r, c, k;
  if (n < 6) { return -1; }
  for (i = 0; i < n; i++)
  {
    double x = xs[i], y = ys[i], z = (x * x) + (y * y);
    sx += x; sy += y; sxx += x * x; syy += y * y; sxy += x * y;
    sz += z; sxz += x * z; syz += y * z;
  }
  a[0][0] = sxx; a[0][1] = sxy; a[0][2] = sx; a[0][3] = -sxz;
  a[1][0] = sxy; a[1][1] = syy; a[1][2] = sy; a[1][3] = -syz;
  a[2][0] = sx;  a[2][1] = sy;  a[2][2] = n;  a[2][3] = -sz;
  for (c = 0; c < 3; c++)
  {
    int piv = c;
    for (r = c + 1; r < 3; r++) { if (fabs(a[r][c]) > fabs(a[piv][c])) { piv = r; } }
    if (fabs(a[piv][c]) < 1e-9) { return -1; }
    if (piv != c) { for (k = 0; k < 4; k++) { double t = a[c][k]; a[c][k] = a[piv][k]; a[piv][k] = t; } }
    for (r = 0; r < 3; r++)
    {
      double f;
      if (r == c) { continue; }
      f = a[r][c] / a[c][c];
      for (k = c; k < 4; k++) { a[r][k] -= f * a[c][k]; }
    }
  }
  {
    double D = a[0][3] / a[0][0], E = a[1][3] / a[1][1], F = a[2][3] / a[2][2];
    double cx = -D / 2.0, cy = -E / 2.0, rr = (cx * cx) + (cy * cy) - F;
    if (rr <= 1.0) { return -1; }
    *ocx = (float)cx; *ocy = (float)cy; *orad = (float)sqrt(rr);
  }
  return 0;
}

typedef struct
{
  float cx, cy, r_out, r_in, score;
  int n, trans;
} eval_t;

static int eval_cand(const uint8_t *cmap, int W, int H, uint8_t id, const cand_t *cd, eval_t *ev)
{
  static float rr[180];
  static float srt[180];
  static float px[180];
  static float py[180];
  float cx = 0.5f * (float)(cd->minx + cd->maxx);
  float cy = 0.5f * (float)(cd->miny + cd->maxy);
  float R0 = 0.5f * (float)(((cd->maxx - cd->minx) > (cd->maxy - cd->miny)) ?
                            (cd->maxx - cd->minx) : (cd->maxy - cd->miny));
  float R = R0, rin, rp, mean;
  int it, k, n, bestn = 0, trans = 0;
  float best = 0.0f;
  uint8_t prof[360];

  for (it = 0; it < 3; it++)
  {
    float thr;
    cast_rays(cmap, W, H, id, cx, cy, R0 * 1.4f + 2.0f, rr);
    memcpy(srt, rr, sizeof(srt));
    sort_f(srt, 180);
    thr = srt[179] * 0.86f;
    n = 0;
    for (k = 0; k < 180; k++)
    {
      if (rr[k] >= thr)
      {
        px[n] = cx + (rr[k] * s_c360[k * 2]);
        py[n] = cy + (rr[k] * s_s360[k * 2]);
        n++;
      }
    }
    {
      float ncx, ncy, nr;
      if (fit_circle_f(px, py, n, &ncx, &ncy, &nr) != 0) { return -1; }
      if ((fabsf(ncx - cx) > R0) || (fabsf(ncy - cy) > R0)) { return -1; }
      cx = ncx; cy = ncy; R = nr;
    }
  }
  cast_rays(cmap, W, H, id, cx, cy, R * 1.3f + 2.0f, rr);
  for (k = 0; k < 180; k++) { g_star_rmax[k] = (uint16_t)(rr[k] * 4.0f); }
  memcpy(srt, rr, sizeof(srt));
  sort_f(srt, 180);
  rin = srt[18];
  if ((R < 8.0f) || (rin > (0.92f * R))) { return -1; }
  rp = 0.5f * (rin + R);
  mean = 0.0f;
  for (k = 0; k < 360; k++)
  {
    int x = (int)(cx + (rp * s_c360[k]) + 0.5f);
    int y = (int)(cy + (rp * s_s360[k]) + 0.5f);
    uint8_t v = 0U;
    if ((x >= 0) && (y >= 0) && (x < W) && (y < H) && (cmap[(y * W) + x] == id)) { v = 1U; }
    prof[k] = v;
    mean += (float)v;
  }
  mean /= 360.0f;
  for (k = 0; k < 360; k++)
  {
    if ((prof[k] == 1U) && (prof[(k + 1) % 360] == 0U)) { trans++; }
  }
  for (n = 3; n <= 12; n++)
  {
    float c = 0.0f, s = 0.0f, mag;
    for (k = 0; k < 360; k++)
    {
      float v = (float)prof[k] - mean;
      int a = (n * k) % 360;
      c += v * s_c360[a];
      s += v * s_s360[a];
    }
    mag = 2.0f * sqrtf((c * c) + (s * s)) / 360.0f;
    if (mag > best) { best = mag; bestn = n; }
  }
  ev->cx = cx; ev->cy = cy; ev->r_out = R; ev->r_in = rin;
  ev->n = bestn; ev->trans = trans; ev->score = best;
  if (best < 0.25f) { return -1; }
  if ((trans != bestn) && (best < 0.40f)) { return -1; }
  return 0;
}

/* 在原图亮度上按半径扫 N 次谐波幅度，采样圆环放在齿/缺口明暗交替最强的那一段。 */
uint16_t g_star_rad_amp[STAR_RAD_MAX];   /* 每个半径（原图像素）的 N 次谐波幅度 ×10 */
uint16_t g_star_rad_n;

static int pick_annulus(const uint16_t *rgb, uint16_t stride, int w, int h,
                        float cx, float cy, int n, float r_out, int *o_r0, int *o_r1, int *o_rpk)
{
  int ra = (int)(0.45f * r_out), rb = (int)(1.35f * r_out) + 2;
  int r, k, rpk = -1, r0, r1;
  float amax = 0.0f;
  static float amp[STAR_RAD_MAX];
  if (ra < 3) { ra = 3; }
  if (rb >= (int)STAR_RAD_MAX) { rb = (int)STAR_RAD_MAX - 1; }
  g_star_rad_n = 0U;
  if ((n < 3) || (rb <= ra)) { return -1; }
  for (r = 0; r < (int)STAR_RAD_MAX; r++) { amp[r] = 0.0f; g_star_rad_amp[r] = 0U; }
  for (r = ra; r <= rb; r++)
  {
    float c = 0.0f, s = 0.0f, m = 0.0f;
    int cnt = 0, out = 0;
    for (k = 0; k < 360; k++)
    {
      int x = (int)(cx + ((float)r * s_c360[k]) + 0.5f);
      int y = (int)(cy + ((float)r * s_s360[k]) + 0.5f);
      int ch, Y, a;
      if ((x < 0) || (y < 0) || (x >= w) || (y >= h)) { out++; continue; }
      Y = px_luma_chroma(rgb[((uint32_t)y * stride) + (uint32_t)x], &ch);
      a = (n * k) % 360;
      c += (float)Y * s_c360[a];
      s += (float)Y * s_s360[a];
      m += (float)Y;
      cnt++;
    }
    if ((out > 18) || (cnt == 0)) { continue; }   /* 圆出了画面就不用 */
    (void)m;
    amp[r] = 2.0f * sqrtf((c * c) + (s * s)) / (float)cnt;
    g_star_rad_amp[r] = (uint16_t)(amp[r] * 10.0f);
    if (amp[r] > amax) { amax = amp[r]; rpk = r; }
  }
  g_star_rad_n = (uint16_t)(rb + 1);
  if ((rpk < 0) || (amax < 12.0f)) { return -1; }
  r0 = rpk; r1 = rpk;
  while ((r0 > ra) && (amp[r0 - 1] >= (0.6f * amax))) { r0--; }
  while ((r1 < rb) && (amp[r1 + 1] >= (0.6f * amax))) { r1++; }
  /* 边上留 1 像素，保证至少 6 像素宽 */
  if ((r1 - r0) > 8) { r0++; r1--; }
  while ((r1 - r0) < 6) { if (r0 > ra) { r0--; } if (r1 < rb) { r1++; } if ((r0 <= ra) && (r1 >= rb)) { break; } }
  *o_r0 = r0; *o_r1 = r1; *o_rpk = rpk;
  return 0;
}

static int locate_once(const uint16_t *rgb, uint16_t stride, uint16_t w, uint16_t h, uint8_t ds,
                       uint8_t *work, uint32_t work_bytes, uint16_t skip_x1, uint16_t skip_y1, int tmode);

uint8_t g_star_tmode;   /* 最近一次定位成功用的阈值：1=暗峰-中位数插值，0=中位数×55% */

int StarTrack_Locate(const uint16_t *rgb, uint16_t stride, uint16_t w, uint16_t h, uint8_t ds,
                     uint8_t *work, uint32_t work_bytes, uint16_t skip_x1, uint16_t skip_y1)
{
  if (locate_once(rgb, stride, w, h, ds, work, work_bytes, skip_x1, skip_y1, 1) == 0)
  {
    g_star_tmode = 1U;
    return 0;
  }
  if (locate_once(rgb, stride, w, h, ds, work, work_bytes, skip_x1, skip_y1, 0) == 0)
  {
    g_star_tmode = 0U;
    return 0;
  }
  return -1;
}

static int locate_once(const uint16_t *rgb, uint16_t stride, uint16_t w, uint16_t h, uint8_t ds,
                       uint8_t *work, uint32_t work_bytes, uint16_t skip_x1, uint16_t skip_y1, int tmode)
{
  int W, H, x, y, i;
  uint8_t *mask;
  uint8_t *cmap;
  uint32_t *queue;
  uint32_t hist[256];
  uint32_t tot = 0U, acc = 0U;
  int med = 128, T;
  cand_t cands[MAX_CAND];
  int nc = 0;
  eval_t best_ev;
  int best_i = -1;

  if ((rgb == 0) || (work == 0) || (ds < 1U)) { return -1; }
  trig_init();
  W = (int)w / (int)ds;
  H = (int)h / (int)ds;
  if ((W < 16) || (H < 16)) { return -1; }
  if (((uint32_t)W * (uint32_t)H * 6U) > work_bytes) { return -1; }
  mask = work;
  cmap = work + ((uint32_t)W * (uint32_t)H);
  queue = (uint32_t *)(void *)(work + (((((uint32_t)W * (uint32_t)H * 2U) + 7U) / 8U) * 8U));

  memset(hist, 0, sizeof(hist));
  for (y = 0; y < H; y++)
  {
    const uint16_t *row = rgb + ((uint32_t)(y * (int)ds) * stride);
    for (x = 0; x < W; x++)
    {
      int ch;
      int Y = px_luma_chroma(row[x * (int)ds], &ch);
      uint8_t *m = &mask[(y * W) + x];
      int skip = (((x * (int)ds) < (int)skip_x1) && ((y * (int)ds) < (int)skip_y1)) ? 1 : 0;
      *m = (uint8_t)Y;
      cmap[(y * W) + x] = (uint8_t)((skip != 0) ? 1U : ((ch < CHROMA_MAX) ? 0U : 2U));
      if (skip == 0) { hist[Y]++; tot++; }
    }
  }
  for (i = 0; i < 256; i++)
  {
    acc += hist[i];
    if ((acc * 2U) >= tot) { med = i; break; }
  }
  T = (med * DARK_PCT) / 100;
  {
    /* Otsu 双峰阈值：小窗里轮子占比大，中位数×55% 会落在轮面亮度里（齿被切掉）。 */
    /* 暗峰（第 5 百分位）与中位数之间取 STAR_T_FRAC，比固定 55% 更贴近轮面与背景的分界。 */
    uint32_t a5 = 0U;
    int p5 = 0, To;
    for (i = 0; i < 256; i++)
    {
      a5 += hist[i];
      if ((a5 * 20U) >= tot) { p5 = i; break; }
    }
    To = p5 + (((med - p5) * STAR_T_FRAC) / 100);
    if ((tmode != 0) && (To > T)) { T = To; }
  }
  if (T < 30) { T = 30; }
  if (T > 180) { T = 180; }
  g_star.med = (uint16_t)med;
  g_star.thr = (uint16_t)T;
  /* mask: 1 = 暗且低饱和、未访问；0 = 其它 */
  for (i = 0; i < (W * H); i++)
  {
    uint8_t v = (uint8_t)(((int)mask[i] < T) && (cmap[i] == 0U));
    mask[i] = v;
    cmap[i] = 0U;
  }
  /* 连通域：广度优先，队列里留着本域像素，合格的写进 cmap（候选号 1..24） */
  for (y = 0; y < H; y++)
  {
    for (x = 0; x < W; x++)
    {
      uint32_t qh = 0U, qt = 0U;
      cand_t cd;
      int edge = 0;
      int bw, bh, dfull;
      if (mask[(y * W) + x] != 1U) { continue; }
      mask[(y * W) + x] = 2U;
      queue[qt++] = ((uint32_t)y << 16) | (uint32_t)x;
      cd.area = 0; cd.minx = (int16_t)x; cd.maxx = (int16_t)x; cd.miny = (int16_t)y; cd.maxy = (int16_t)y;
      while (qh < qt)
      {
        uint32_t e = queue[qh++];
        int ex = (int)(e & 0xFFFFU), ey = (int)(e >> 16);
        int nb;
        cd.area++;
        if (ex < cd.minx) { cd.minx = (int16_t)ex; }
        if (ex > cd.maxx) { cd.maxx = (int16_t)ex; }
        if (ey < cd.miny) { cd.miny = (int16_t)ey; }
        if (ey > cd.maxy) { cd.maxy = (int16_t)ey; }
        if ((ex == 0) || (ey == 0) || (ex == (W - 1)) || (ey == (H - 1))) { edge = 1; }
        for (nb = 0; nb < 4; nb++)
        {
          int nx = ex, ny = ey;
          if (nb == 0) { nx++; } else if (nb == 1) { nx--; } else if (nb == 2) { ny++; } else { ny--; }
          if ((nx < 0) || (ny < 0) || (nx >= W) || (ny >= H)) { continue; }
          if (mask[(ny * W) + nx] == 1U)
          {
            mask[(ny * W) + nx] = 2U;
            queue[qt++] = ((uint32_t)ny << 16) | (uint32_t)nx;
          }
        }
      }
      bw = cd.maxx - cd.minx + 1;
      bh = cd.maxy - cd.miny + 1;
      dfull = ((bw > bh) ? bw : bh) * (int)ds;
      if (edge != 0) { continue; }
      if ((dfull < 50) || (dfull > 320)) { continue; }
      if (((bw * 4) < (bh * 3)) || ((bh * 4) < (bw * 3))) { continue; }
      if (((cd.area * 100) < (bw * bh * FILL_MIN)) || ((cd.area * 100) > (bw * bh * 85))) { continue; }
      if (nc >= MAX_CAND) { continue; }
      cands[nc] = cd;
      nc++;
      for (qh = 0U; qh < qt; qh++)
      {
        uint32_t e = queue[qh];
        cmap[((int)(e >> 16) * W) + (int)(e & 0xFFFFU)] = (uint8_t)nc;
      }
    }
  }
  g_star.ncand = (uint8_t)nc;
  for (i = 0; i < nc; i++)
  {
    eval_t ev;
    if (eval_cand(cmap, W, H, (uint8_t)(i + 1), &cands[i], &ev) != 0) { continue; }
    if ((best_i < 0) || (ev.score > best_ev.score)) { best_ev = ev; best_i = i; }
  }
  if (best_i < 0)
  {
    g_star.found = 0U;
    return -1;
  }
  {
    float f = (float)ds;
    float off = 0.5f * (f - 1.0f);
    g_star.cx = (int16_t)((best_ev.cx * f) + off + 0.5f);
    g_star.cy = (int16_t)((best_ev.cy * f) + off + 0.5f);
    g_star.r_out = (int16_t)((best_ev.r_out * f) + 0.5f);
    g_star.r_in = (int16_t)((best_ev.r_in * f) + 0.5f);
    g_star.n_teeth = (uint8_t)best_ev.n;
    g_star.trans = (uint16_t)best_ev.trans;
    g_star.score_e3 = (uint16_t)(best_ev.score * 1000.0f);
    g_star.ann_r0 = 0;
    g_star.ann_r1 = 0;
    g_star.ann_pk = 0;
    {
      int a0 = 0, a1 = 0, apk = 0;
      if (pick_annulus(rgb, stride, (int)w, (int)h, (best_ev.cx * f) + off, (best_ev.cy * f) + off,
                       best_ev.n, best_ev.r_out * f, &a0, &a1, &apk) != 0)
      {
        g_star.found = 0U;
        return -1;
      }
      g_star.ann_r0 = (int16_t)a0;
      g_star.ann_r1 = (int16_t)a1;
      g_star.ann_pk = (int16_t)apk;
      if (a1 > g_star.r_out) { g_star.r_out = (int16_t)a1; }
    }
    g_star.found = 1U;
  }
  return 0;
}

/* ======================= 行中断采样 ======================= */

void StarTrack_Disarm(void)
{
  s_tab_on = 0U;
  g_star.armed = 0U;
}

int StarTrack_Arm(uint16_t cap_w, uint16_t cap_h)
{
  int cx = g_star.cx, cy = g_star.cy;
  float ro = (float)g_star.r_out, ri = (float)g_star.r_in;
  float r0 = ri + (0.15f * (ro - ri));
  float r1 = ro - (0.12f * (ro - ri));
  if ((g_star.ann_r1 > g_star.ann_r0) && (g_star.ann_r0 > 0))
  {
    /* 定位时按亮度径向扫描选好的齿带 */
    r0 = (float)g_star.ann_r0;
    r1 = (float)g_star.ann_r1 + 0.5f;
  }
  int y0, y1, x, y, k, step = 1, pass;
  uint32_t n = 0U;
  uint32_t cnt[STAR_BINS];
  StarTrack_Disarm();
  if ((g_star.found == 0U) || (g_star.n_teeth < 3U) || ((r1 - r0) < 2.0f)) { return -1; }
  y0 = cy - (int)r1 - 1; if (y0 < 0) { y0 = 0; }
  y1 = cy + (int)r1 + 2; if (y1 > (int)cap_h) { y1 = (int)cap_h; }
  if ((y1 - y0) > (int)STAR_ROW_MAX) { return -1; }
  for (pass = 0; pass < 3; pass++)
  {
    n = 0U;
    memset(cnt, 0, sizeof(cnt));
    for (y = y0; y < y1; y++)
    {
      float dy = (float)(y - cy);
      s_row_start[y - y0] = (uint16_t)n;
      for (x = cx - (int)r1 - 1; x <= (cx + (int)r1 + 1); x += step)
      {
        float dx = (float)(x - cx);
        float d2 = (dx * dx) + (dy * dy);
        float a;
        int b;
        if ((x < 0) || (x >= (int)cap_w)) { continue; }
        if ((d2 < (r0 * r0)) || (d2 > (r1 * r1))) { continue; }
        a = atan2f(dy, dx);
        if (a < 0.0f) { a += ST_TWO_PI; }
        b = (int)((a * (float)STAR_BINS) / ST_TWO_PI);
        if (b >= (int)STAR_BINS) { b = (int)STAR_BINS - 1; }
        if (n < STAR_TAB_MAX) { s_tab[n] = ((uint32_t)x << 8) | (uint32_t)b; }
        n++;
        cnt[b]++;
      }
    }
    if (n <= STAR_TAB_MAX) { break; }
    step++;
  }
  if (n > STAR_TAB_MAX) { return -1; }
  s_row_start[y1 - y0] = (uint16_t)n;
  for (k = 0; k < (int)STAR_BINS; k++)
  {
    float th = (((float)k + 0.5f) * ST_TWO_PI) / (float)STAR_BINS;
    float a = th * (float)g_star.n_teeth;
    if (cnt[k] == 0U) { return -1; }
    s_cosn[k] = cosf(a);
    s_sinn[k] = sinf(a);
    s_cinv[k] = 1.0f / (float)cnt[k];
  }
  g_star.ann_r0 = (int16_t)(r0 + 0.5f);
  g_star.ann_r1 = (int16_t)r1;
  g_star.tab_n = (uint16_t)n;
  track_reset();
  s_row0 = (uint16_t)y0;
  s_row1 = (uint16_t)y1;
  s_ring_tail = s_ring_head;
  s_gen = (uint8_t)(s_gen + 1U);
  g_star_arm_n++;
  s_tab_on = 1U;
  g_star.armed = 1U;
  return 0;
}

void StarTrack_IsrLine(const uint32_t *src)
{
  uint16_t y = s_line;
  s_line = (uint16_t)(y + 1U);
  if ((s_frame_tab == 0U) || (s_tab_on == 0U) || (y < s_row0) || (y >= s_row1))
  {
    return;
  }
  {
    const uint16_t *px = (const uint16_t *)(const void *)src;
    uint32_t i = s_row_start[y - s_row0];
    uint32_t e = s_row_start[(y - s_row0) + 1U];
    for (; i < e; i++)
    {
      uint32_t en = s_tab[i];
      uint32_t p = px[en >> 8];
      s_acc[en & 0xFFU] += ((p >> 11) & 31U) + ((p >> 5) & 63U) + (p & 31U);
    }
  }
}

void StarTrack_IsrFrame(uint32_t stamp_us, uint16_t lines_expect)
{
  uint16_t nl = s_line;
  uint32_t k;
  s_line = 0U;
  g_star_isr_lines = nl;
  if ((s_frame_tab != 0U) && (s_tab_on != 0U) && (s_frame_gen == s_gen) && (nl == lines_expect))
  {
    float c = 0.0f, s = 0.0f, m = 0.0f, amp;
    for (k = 0U; k < STAR_BINS; k++)
    {
      float v = (float)s_acc[k] * s_cinv[k];
      g_star_prof[k] = (uint16_t)(v * 16.0f);
      m += v;
      c += v * s_cosn[k];
      s += v * s_sinn[k];
    }
    m = m / (float)STAR_BINS;
    amp = (2.0f / (float)STAR_BINS) * sqrtf((c * c) + (s * s));
    {
      uint16_t h = s_ring_head;
      uint16_t nh = (uint16_t)((h + 1U) % STAR_RING);
      if (nh != s_ring_tail)
      {
        s_ring[h].stamp = stamp_us;
        s_ring[h].phase = atan2f(s, c);
        s_ring[h].q = (m > 1.0f) ? (amp / m) : 0.0f;
        s_ring_head = nh;
      }
      else
      {
        g_star_ring_drop++;
      }
    }
    g_star_isr_frames++;
  }
  else if (s_tab_on != 0U)
  {
    g_star_isr_bad++;
    if (nl != lines_expect) { g_star_bad_lines = nl; }
  }
  for (k = 0U; k < STAR_BINS; k++) { s_acc[k] = 0U; }
  s_frame_tab = s_tab_on;
  s_frame_gen = s_gen;
}

/* ======================= 主循环测量 ======================= */

static int32_t iabs32(int32_t v) { return (v < 0) ? -v : v; }

static void meas_record(uint32_t dt_us, double ang_deg, uint8_t laps)
{
  uint8_t i = g_star_meas_i;
  double aa = (ang_deg < 0.0) ? -ang_deg : ang_deg;
  g_star_meas_dt_us[i] = dt_us;
  g_star_meas_ang_mdeg[i] = (int32_t)((aa * 1000.0) + 0.5);
  g_star_meas_dps_e3[i] = (int32_t)(((aa * 1.0e9) / (double)dt_us) + 0.5);
  g_star_meas_laps[i] = laps;
  g_star_seq++;
  if (g_star_seq > 999U) { g_star_seq = 1U; }
  g_star_meas_seq[i] = g_star_seq;
  g_star_meas_i = (uint8_t)((i + 1U) % STAR_MEAS_HIST);
  if (g_star_meas_n < STAR_MEAS_HIST) { g_star_meas_n++; }
  if (g_star_meas_n >= 3U)
  {
    double sum = 0.0, ss = 0.0, mean;
    uint8_t k;
    for (k = 0U; k < g_star_meas_n; k++) { sum += (double)g_star_meas_dps_e3[k]; }
    mean = sum / (double)g_star_meas_n;
    for (k = 0U; k < g_star_meas_n; k++)
    {
      double d = (double)g_star_meas_dps_e3[k] - mean;
      ss += d * d;
    }
    if (mean > 0.0)
    {
      double sd = sqrt(ss / (double)(g_star_meas_n - 1U));
      g_star_rep_e4 = (int32_t)(((sd / mean) * 100.0 * 10000.0) + 0.5);
    }
  }
}

/* 测量窗从这一帧重新起算（首帧或断帧后） */
static void restart_windows(uint32_t stamp)
{
  hist_reset();
  s_lap_t0 = stamp;
  s_lap_a0 = g_star_wheel_deg;
  s_mw_t0 = stamp;
  s_mw_ang = 0.0;
  g_star_mw_laps = 0U;
  g_star_lap_deg = 0.0;
  s_meas_on = 1U;
}

/* 每个有效帧调用：满一整圈（360°）按升针同样的规则决定是否出一行。
 * 圈的终点取第一帧转过 >=360° 的那一帧，角度与时间都按这一帧的实测值。 */
static void lap_step(uint32_t stamp)
{
  double d;
  if (s_meas_on == 0U) { return; }
  d = g_star_wheel_deg - s_lap_a0;
  if (d < 0.0) { d = -d; }
  g_star_lap_deg = d;
  if (d < 360.0) { return; }
  {
    uint32_t lap_dt = stamp - s_lap_t0;
    uint32_t tot;
    uint8_t done = 0U;
    s_mw_ang += d;
    if (g_star_mw_laps < 255U) { g_star_mw_laps++; }
    g_star_lap_us = lap_dt;
    tot = stamp - s_mw_t0;
    /* 梅花轮专用：单圈 >=30 s 跑 1 圈；单圈 <30 s 累加整圈到总时长 >30 s。 */
    if (lap_dt >= MW_TOTAL_US)
    {
      g_star_mw_target = 1U;
      done = 1U;
    }
    else
    {
      g_star_mw_target = 0U;
      if (tot > MW_TOTAL_US) { done = 1U; }
    }
    if (done != 0U)
    {
      meas_record(tot, s_mw_ang, g_star_mw_laps);
      s_mw_t0 = stamp;
      s_mw_ang = 0.0;
      g_star_mw_laps = 0U;
    }
    s_lap_t0 = stamp;
    s_lap_a0 = g_star_wheel_deg;
    g_star_lap_deg = 0.0;
  }
}

int StarTrack_Tick(uint32_t now_us)
{
  while (s_ring_tail != s_ring_head)
  {
    star_evt_t e = s_ring[s_ring_tail];
    s_ring_tail = (uint16_t)((s_ring_tail + 1U) % STAR_RING);
    g_star_last_q = e.q;
    if (e.q < MIN_Q)
    {
      g_star_lowq_n++;
      continue;
    }
    g_star_good_n++;
    s_last_good = e.stamp;
    if (s_have_prev == 0U)
    {
      s_have_prev = 1U;
      s_prev_phase = e.phase;
      s_prev_stamp = e.stamp;
      s_phase0 = e.phase;
      restart_windows(e.stamp);
      s_fps_t0 = e.stamp;
      s_fps_n = 0U;
    }
    else
    {
      uint32_t gap = e.stamp - s_prev_stamp;
      if (gap > GAP_US)
      {
        g_star_gap_n++;
        restart_windows(e.stamp);
      }
      else
      {
        float d = e.phase - s_prev_phase;
        while (d > ST_PI) { d -= ST_TWO_PI; }
        while (d <= -ST_PI) { d += ST_TWO_PI; }
        g_star_accum += (double)d / (double)ST_TWO_PI;
        g_star_wheel_deg = (g_star_accum * 360.0) / (double)g_star.n_teeth;
        lap_step(e.stamp);
      }
      s_prev_phase = e.phase;
      s_prev_stamp = e.stamp;
    }
    g_star_last_phase = e.phase;
    g_star_last_stamp = e.stamp;
    s_hist_t[s_hist_i] = e.stamp;
    s_hist_a[s_hist_i] = g_star_accum;
    s_hist_i = (uint16_t)((s_hist_i + 1U) % STAR_HIST);
    if (s_hist_n < STAR_HIST) { s_hist_n++; }
    s_fps_n++;
    if ((e.stamp - s_fps_t0) >= 1000000U)
    {
      g_star_fps_e1 = (int32_t)((((uint64_t)s_fps_n * 10000000ULL) + ((e.stamp - s_fps_t0) / 2U))
                                / (uint64_t)(e.stamp - s_fps_t0));
      s_fps_t0 = e.stamp;
      s_fps_n = 0U;
    }
    {
      /* 白线（缺口中心参考）的当前角度，画面坐标，0~360° */
      double a = (((double)s_phase0 / (double)ST_TWO_PI) + g_star_accum) * 360.0 / (double)g_star.n_teeth;
      a = fmod(a, 360.0);
      if (a < 0.0) { a += 360.0; }
      g_star_ang_mdeg = (int32_t)(a * 1000.0);
    }
  }
  /* 约 2 s 窗口的实时齿/s */
  if (s_hist_n >= 2U)
  {
    uint16_t newest = (uint16_t)((s_hist_i + STAR_HIST - 1U) % STAR_HIST);
    uint16_t k = (uint16_t)((s_hist_i + STAR_HIST - s_hist_n) % STAR_HIST);
    uint16_t left = s_hist_n;
    while ((left > 2U) && ((s_hist_t[newest] - s_hist_t[k]) > RATE_WIN_US))
    {
      k = (uint16_t)((k + 1U) % STAR_HIST);
      left--;
    }
    if ((s_hist_t[newest] - s_hist_t[k]) >= RATE_MIN_US)
    {
      double d = s_hist_a[newest] - s_hist_a[k];
      double dt = (double)(s_hist_t[newest] - s_hist_t[k]);
      g_star_dir = (d < 0.0) ? -1 : 1;
      if (d < 0.0) { d = -d; }
      g_star_tps_e3 = (int32_t)(((d * 1.0e9) / dt) + 0.5);
      g_star_dps_e3 = (int32_t)(((d * 360.0 * 1.0e9) / (dt * (double)g_star.n_teeth)) + 0.5);
    }
  }
  /* 有符号比较：本次刚消化的帧可能比 now_us 晚一点打戳。 */
  if ((s_tab_on != 0U) && (s_have_prev != 0U) && ((int32_t)(now_us - s_last_good) > (int32_t)LOST_US))
  {
    g_star_lost_n++;
    return 1;
  }
  return 0;
}

/* ======================= 画图 ======================= */

static void fill_rect(uint16_t *fb, int fb_w, int fb_h, int x0, int y0, int x1, int y1, uint16_t c)
{
  int x, y;
  if (x0 < 0) { x0 = 0; }
  if (y0 < 0) { y0 = 0; }
  if (x1 > fb_w) { x1 = fb_w; }
  if (y1 > fb_h) { y1 = fb_h; }
  for (y = y0; y < y1; y++)
  {
    uint16_t *row = fb + (y * fb_w);
    for (x = x0; x < x1; x++) { row[x] = c; }
  }
}

static void plot(uint16_t *fb, int fb_w, int fb_h, int x, int y, uint16_t c, int t, int cx0, int cy0, int cx1, int cy1)
{
  int dx, dy;
  for (dy = -(t / 2); dy <= (t / 2); dy++)
  {
    for (dx = -(t / 2); dx <= (t / 2); dx++)
    {
      int px = x + dx, py = y + dy;
      if ((px < cx0) || (py < cy0) || (px >= cx1) || (py >= cy1)) { continue; }
      if ((px < 0) || (py < 0) || (px >= fb_w) || (py >= fb_h)) { continue; }
      fb[(py * fb_w) + px] = c;
    }
  }
}

static void draw_circle(uint16_t *fb, int fb_w, int fb_h, int cx, int cy, int R, uint16_t c,
                        int t, int stepdeg, int cx0, int cy0, int cx1, int cy1)
{
  int a;
  trig_init();
  for (a = 0; a < 360; a += stepdeg)
  {
    int x = cx + (int)((s_c360[a] * (float)R) + ((s_c360[a] >= 0.0f) ? 0.5f : -0.5f));
    int y = cy + (int)((s_s360[a] * (float)R) + ((s_s360[a] >= 0.0f) ? 0.5f : -0.5f));
    plot(fb, fb_w, fb_h, x, y, c, t, cx0, cy0, cx1, cy1);
  }
}

static void draw_ray(uint16_t *fb, int fb_w, int fb_h, int cx, int cy, float ang, int r0, int r1,
                     uint16_t c, int t, int cx0, int cy0, int cx1, int cy1)
{
  float co = cosf(ang), si = sinf(ang);
  int r;
  for (r = r0; r <= r1; r++)
  {
    int x = cx + (int)((co * (float)r) + ((co >= 0.0f) ? 0.5f : -0.5f));
    int y = cy + (int)((si * (float)r) + ((si >= 0.0f) ? 0.5f : -0.5f));
    plot(fb, fb_w, fb_h, x, y, c, t, cx0, cy0, cx1, cy1);
  }
}

static const uint8_t star_extra_bits[1014] = {
  0xA4,0x1A,0x00,0x00,0x00,0x00,0x60,0xFF,0x02,0x00,0x00,0x00,0x00,0xF6,0x2F,0x00,
  0x00,0x00,0x00,0x60,0xFF,0x02,0x00,0x00,0x00,0x00,0xF6,0x2F,0x00,0x00,0x00,0x00,
  0x60,0xFF,0x02,0x00,0x00,0x00,0x00,0xF6,0x2F,0x00,0x00,0x00,0x00,0x60,0xFF,0x01,
  0xB5,0xEE,0x5B,0x00,0xF6,0x1F,0xF9,0xFF,0xFF,0x7F,0x60,0xFF,0xFD,0x5A,0x84,0xFF,
  0x1F,0xF6,0xFF,0x04,0x00,0x60,0xFF,0x66,0xFF,0x04,0x00,0x00,0xF0,0x9F,0xF6,0x2F,
  0x00,0x00,0x00,0xFE,0x6A,0xFF,0x02,0x00,0x00,0xD0,0xBF,0xF6,0x2F,0x00,0x00,0x00,
  0xFD,0x6B,0xFF,0x02,0x00,0x00,0xD0,0xBF,0xF6,0x2F,0x00,0x00,0x00,0xFD,0x6B,0xFF,
  0x02,0x00,0x00,0xD0,0xBF,0xF6,0x2F,0x00,0x00,0x00,0xFD,0x6B,0xFF,0x02,0x00,0x00,
  0xD0,0xBF,0xF6,0x2F,0x00,0x00,0x00,0xFD,0x6B,0xFF,0x02,0x00,0x00,0xD0,0xBF,0xA4,
  0x1A,0x60,0xFF,0x02,0xF6,0x2F,0x60,0xFF,0x02,0xF6,0x2F,0x60,0xFF,0x02,0xF6,0x2F,
  0x60,0xFF,0x02,0xF6,0x2F,0x60,0xFF,0x02,0xF6,0x2F,0x60,0xFF,0x02,0xF6,0x2F,0x60,
  0xFF,0x02,0xF6,0x2F,0x60,0xFF,0x02,0xF6,0x2F,0x60,0xFF,0x02,0xF6,0x2F,0x60,0xFF,
  0x02,0xF5,0x7F,0x10,0xFF,0x7F,0x50,0xFD,0x09,0xF6,0x0B,0x60,0xFC,0xCE,0x05,0x00,
  0xF6,0x3D,0xFD,0xFF,0xFF,0x9F,0x00,0xF6,0xFF,0x9F,0x35,0xD6,0xFF,0x08,0xF6,0xCF,
  0x02,0x00,0x10,0xFC,0x1F,0xF6,0x2F,0x00,0x00,0x00,0xF5,0x7F,0xF6,0x2F,0x00,0x00,
  0x00,0xF0,0xAF,0xF6,0x2F,0x00,0x00,0x00,0xE0,0xCF,0xF6,0x2F,0x00,0x00,0x00,0xD0,
  0xDF,0xF6,0x2F,0x00,0x00,0x00,0xF0,0xCF,0xF6,0x2F,0x00,0x00,0x00,0xF2,0x9F,0xF6,
  0x2F,0x00,0x00,0x00,0xF9,0x4F,0xF6,0x7F,0x00,0x00,0x40,0xFF,0x0B,0xF6,0xFF,0x6C,
  0x43,0xF8,0xFF,0x02,0xF6,0x9F,0xFF,0xFF,0xFF,0x3D,0x00,0xF6,0x1F,0x92,0xFD,0x8D,
  0x00,0x00,0xF6,0x1F,0x00,0x00,0x00,0x00,0x00,0xF6,0x2F,0x00,0x00,0x00,0x00,0x00,
  0xF6,0x2F,0x00,0x00,0x00,0x00,0x00,0xF6,0x2F,0x00,0x00,0x00,0x00,0x00,0xF6,0x2F,
  0x00,0x00,0x00,0x00,0x00,0xF6,0x2F,0x00,0x00,0x00,0x00,0x00,0xF6,0x2F,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x31,0x01,0x00,0x00,0x00,0x80,0x5F,0x00,0x00,
  0x00,0x00,0xFD,0x00,0x00,0x00,0x00,0xF2,0x0B,0x00,0x00,0x00,0x70,0x6F,0x00,0x00,
  0x00,0x00,0xFC,0x01,0x00,0x00,0x00,0xF1,0x0C,0x00,0x00,0x00,0x60,0x7F,0x00,0x00,
  0x00,0x00,0xFA,0x02,0x00,0x00,0x00,0xF0,0x0D,0x00,0x00,0x00,0x40,0x8F,0x00,0x00,
  0x00,0x00,0xF9,0x03,0x00,0x00,0x00,0xE0,0x0E,0x00,0x00,0x00,0x30,0xAF,0x00,0x00,
  0x00,0x00,0xF8,0x05,0x00,0x00,0x00,0xD0,0x0F,0x00,0x00,0x00,0x20,0xBF,0x00,0x00,
  0x00,0x00,0xF7,0x06,0x00,0x00,0x00,0xC0,0x1F,0x00,0x00,0x00,0x10,0xCF,0x00,0x00,
  0x00,0x00,0xF6,0x07,0x00,0x00,0x00,0xB0,0x2F,0x00,0x00,0x00,0x00,0xDF,0x00,0x00,
  0x00,0x00,0xF5,0x08,0x00,0x00,0x00,0x90,0x3F,0x00,0x00,0x00,0x00,0xEE,0x00,0x00,
  0x00,0x00,0xF3,0x0A,0x00,0x00,0x00,0x80,0x5F,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0xFD,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x08,0x00,0x00,
  0xFD,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xF1,0x0F,0x00,0x00,0xFD,0x04,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0xF1,0x0F,0x00,0x00,0xFD,0xFF,0xFF,0xFF,0xFF,0x2F,
  0x00,0x00,0x00,0xF1,0x0F,0x00,0x00,0xFD,0xCD,0xCC,0xCC,0xCC,0x2C,0x00,0x00,0x00,
  0xF1,0x0F,0x00,0x00,0xFD,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xF1,0x0F,0x00,
  0x00,0xFD,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xF1,0x0F,0x00,0x00,0xFD,0x04,
  0x00,0x00,0x00,0x00,0x00,0xE5,0xEE,0xFE,0xEF,0xEE,0xEE,0xFF,0xEF,0xEE,0xEE,0xEE,
  0xEE,0x9E,0xF6,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x9F,0x00,
  0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xD8,0x07,0x00,
  0x00,0x00,0xFB,0x05,0x00,0x00,0x40,0xCD,0x00,0x00,0xF9,0x08,0x00,0x00,0x00,0xFF,
  0x01,0x00,0x00,0x40,0xDF,0x00,0x00,0xF9,0x08,0x00,0x00,0x50,0xCF,0x00,0x00,0x00,
  0x40,0xDF,0x00,0x00,0xF9,0x08,0x00,0x00,0xB0,0xAF,0x00,0x00,0x00,0x40,0xDF,0x00,
  0x00,0xF9,0x08,0x00,0x00,0xF4,0xFF,0x1B,0x00,0x00,0x40,0xDF,0x00,0x00,0xF9,0x08,
  0x00,0x00,0xFD,0xD8,0xDF,0x02,0x00,0x40,0xDF,0x00,0x00,0xF9,0x08,0x00,0xA0,0xAF,
  0x00,0xFA,0x5F,0x00,0x40,0xDF,0x00,0x00,0xF9,0x08,0x00,0xF9,0x1E,0x00,0x80,0xFF,
  0x08,0x40,0xDF,0x00,0x00,0xF9,0x08,0xA1,0xFF,0x03,0x00,0x00,0xF5,0xAF,0x40,0xDF,
  0x00,0x00,0xF9,0x48,0xFE,0x2D,0x00,0x00,0x00,0x40,0xFF,0x48,0xDF,0x00,0x00,0xF9,
  0x18,0xBC,0x01,0x00,0x00,0x00,0x00,0xC3,0x41,0xDF,0x00,0x00,0xF9,0x08,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x40,0xDF,0x00,0x00,0xF9,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
  0xFF,0xFF,0xFF,0xDF,0x00,0x00,0xF9,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
  0xDF,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0xDF,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x22,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0xD0,0x0F,0x00,0xB5,0x6B,0x00,0x00,0xF0,0x0F,0x30,0xFF,0xFF,0x05,
  0x00,0xFD,0x0D,0x60,0xFF,0xFF,0x09,0x00,0xDF,0x00,0x50,0xFF,0xFF,0x07,0xF0,0x0F,
  0x00,0x00,0xF9,0xBF,0x01,0xFD,0x0D,0x00,0x00,0x30,0x03,0x00,0xFF,0x00,0x00,0x00,
  0x00,0x00,0xD0,0xDF,0x00,0x00,0x00,0x00,0x00,0xF0,0x0F,0x00,0x00,0x00,0x00,0x00,
  0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0xDF,0x00,0x00,0x00,0x00,0x00,0xF0,0x0F,0x00,
  0x00,0x00,0x00,0x00,0xFD,0x0D,0x30,0x56,0x00,0x00,0x00,0xFF,0x00,0xE5,0xFF,0x09,
  0x00,0xD0,0x0F,0x00,0xFB,0xFF,0x3F,0x00,0xF0,0x0F,0x00,0xFB,0xFF,0x3F,0x00,0xFD,
  0x00,0x00,0xF6,0xFF,0x0B,0x00,0xDF,0x00,0x00,0x50,0x79,0x01,0x00,0x0C,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

static const dial_glyph_t star_extra_glyphs[6] = {
  {0x68, 2, 11, 13, 22, 1088, &star_extra_bits[0]},    /* h */
  {0x6C, 2, 10, 5, 23, 509, &star_extra_bits[143]},    /* l */
  {0x70, 2, 18, 14, 22, 1111, &star_extra_bits[201]},  /* p */
  {0x2F, 0, 10, 11, 28, 702, &star_extra_bits[355]},   /* / */
  {0xD7, 1, 9, 26, 27, 1792, &star_extra_bits[509]},   /* 齿 */
  {0x25, 1, 11, 14, 22, 1024, &star_extra_bits[860]},  /* % */
};

static const uint8_t star_cjk_bits[1856] = {
  0x00,0x00,0x74,0x01,0x00,0x00,0x62,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x90,0x3F,
  0x00,0x00,0x80,0x6F,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xF9,0x03,0x00,0x00,0xFE,
  0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x90,0x3F,0x00,0x00,0xF4,0xBE,0xBB,0xBB,0xBB,
  0xBB,0x4B,0x00,0x00,0xF9,0x03,0x00,0xA0,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x06,0x00,
  0x90,0x3F,0x00,0x40,0xCF,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0xCC,0xFE,0xCD,0x08,
  0xFC,0x05,0x00,0x00,0x00,0x00,0x00,0x00,0xFA,0xFF,0xFF,0xAF,0xF7,0x0C,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0xFD,0x03,0x90,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0x5F,
  0x00,0x00,0xF1,0x7F,0x00,0x30,0xF2,0xAD,0xAA,0xAA,0xAA,0xFC,0x04,0x00,0x50,0xFF,
  0x2E,0x00,0x40,0x8F,0x60,0x1A,0x00,0x80,0x4F,0x00,0x00,0xF8,0xFF,0x0A,0x00,0xF5,
  0x06,0xF6,0x4E,0x00,0xF8,0x03,0x00,0xC0,0xFF,0xFA,0x03,0x70,0x5F,0x00,0xD3,0x4F,
  0x90,0x3F,0x00,0x10,0xFF,0x4F,0xCE,0x00,0xF8,0x03,0x00,0x81,0x00,0xF9,0x02,0x00,
  0xF5,0xFC,0x83,0xBB,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x0E,0xB0,0x9D,0x3F,0x22,
  0xB8,0xFE,0xBB,0xBB,0xBB,0xBB,0xFE,0xAB,0x10,0x8F,0xF9,0x03,0x00,0xE0,0x0D,0xC1,
  0x07,0x00,0xB0,0x0F,0x00,0xF8,0x93,0x3F,0x00,0x10,0xBF,0x00,0xF8,0x2B,0x00,0xFC,
  0x00,0xF1,0x0C,0xF9,0x03,0x00,0xF3,0x09,0x00,0xE5,0x0C,0xD0,0x0E,0x00,0x4A,0x90,
  0x3F,0x00,0x50,0x7F,0x00,0x00,0x33,0x00,0xCE,0x00,0x10,0x00,0xF9,0x03,0x00,0xF8,
  0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x09,0x00,0x90,0x3F,0x00,0x60,0xAA,0xAA,0xAA,0xAA,
  0xBA,0xDF,0x6A,0x00,0x00,0xF9,0x03,0x00,0x00,0x00,0x00,0x00,0x00,0xF7,0x06,0x00,
  0x00,0x90,0x3F,0x00,0x00,0x00,0x00,0x00,0x99,0xE9,0x2F,0x00,0x00,0x00,0xF9,0x03,
  0x00,0x00,0x00,0x00,0xB0,0xFF,0x6E,0x00,0x00,0x00,0x40,0x16,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x71,0x05,0x00,0x00,0x40,0x27,0x00,0x00,
  0x00,0x00,0x00,0x00,0xF3,0x0B,0x00,0x00,0xA0,0x5F,0x00,0x00,0x00,0x00,0x00,0x00,
  0xF3,0x0B,0x00,0x00,0xA0,0x5F,0x00,0x00,0x00,0xD6,0xDD,0xDD,0xFD,0xDF,0xDD,0xDD,
  0xED,0xEF,0xDD,0xDD,0x5D,0xF7,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
  0x6F,0x00,0x00,0x00,0xF3,0x0B,0x00,0x00,0xA0,0x5F,0x00,0x00,0x00,0x00,0x00,0x00,
  0xF3,0x0B,0x00,0x00,0xA0,0x5F,0x00,0x00,0x00,0x00,0x00,0x00,0x51,0x04,0x00,0x00,
  0x50,0x27,0x00,0x00,0x00,0x00,0x00,0x00,0xD5,0x06,0x00,0xE7,0x07,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0xFD,0x04,0x00,0xF7,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0x70,
  0xBF,0x00,0x00,0xF7,0x08,0x00,0x00,0x76,0x00,0x00,0x00,0xF3,0x2F,0x00,0x00,0xF7,
  0x08,0x00,0xA1,0xFF,0x04,0x00,0x10,0xFD,0x0A,0x00,0x00,0xF7,0x08,0x40,0xFD,0x7F,
  0x00,0x00,0xB0,0xFF,0x09,0x00,0x00,0xF7,0x28,0xFA,0xCF,0x02,0x00,0x00,0xFA,0xFF,
  0x09,0x00,0x00,0xF7,0xEC,0xEF,0x06,0x00,0x00,0xB1,0xEF,0xF9,0x09,0x00,0x00,0xF9,
  0xEF,0x18,0x00,0x00,0x00,0xF5,0x3E,0xF6,0x09,0x10,0xD7,0xFF,0x1B,0x00,0x00,0x00,
  0x00,0x50,0x03,0xF6,0x09,0xE4,0xEF,0xFD,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0xF6,
  0x09,0xD1,0x18,0xF7,0x08,0x00,0x00,0x00,0x00,0x00,0x00,0xF6,0x09,0x00,0x00,0xF7,
  0x08,0x00,0x00,0x00,0x7C,0x00,0x00,0xF6,0x09,0x00,0x00,0xF7,0x08,0x00,0x00,0x00,
  0xDF,0x00,0x00,0xF6,0x09,0x00,0x00,0xF7,0x08,0x00,0x00,0x10,0xCF,0x00,0x00,0xF6,
  0x09,0x00,0x00,0xF6,0x0A,0x00,0x00,0x60,0x9F,0x00,0x00,0xF6,0x09,0x00,0x00,0xF3,
  0xEF,0xDD,0xDD,0xFD,0x4F,0x00,0x00,0xF6,0x09,0x00,0x00,0x70,0xFD,0xFF,0xFF,0xDF,
  0x07,0x00,0x00,0x62,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x14,
  0x00,0x00,0x00,0x00,0x20,0x14,0x00,0x00,0x00,0x00,0x20,0xBF,0x00,0x00,0x00,0x00,
  0xA0,0x9F,0x00,0x00,0x00,0x00,0x50,0x8F,0x00,0x00,0x00,0x00,0xF1,0xAF,0x00,0x00,
  0x00,0x00,0x70,0x5F,0x00,0x00,0x00,0x00,0xF8,0xFF,0x03,0x00,0x00,0xFC,0xFF,0xFF,
  0xFF,0x6F,0x00,0x20,0xFE,0xF8,0x0C,0x00,0x00,0xDA,0xFD,0xDF,0xDD,0x6D,0x00,0xA0,
  0xAF,0xA0,0x7F,0x00,0x00,0x00,0xF2,0x09,0x00,0x00,0x00,0xF5,0x2E,0x10,0xFE,0x03,
  0x00,0x00,0xF6,0x04,0x00,0x00,0x30,0xFE,0x05,0x00,0xF5,0x2D,0x00,0x00,0xFA,0xE1,
  0x0B,0x00,0xD2,0x9F,0x00,0x00,0xA0,0xDF,0x01,0x00,0xBE,0xF0,0x0B,0x20,0xFD,0x0B,
  0x00,0x00,0x10,0xFC,0x2D,0x50,0x5F,0xF0,0x0B,0xE1,0xCF,0x54,0x01,0x00,0x00,0xD1,
  0xBF,0xB0,0x1F,0xF0,0x0B,0x80,0x1B,0xFB,0x03,0x00,0x00,0x10,0x1A,0xF4,0xBE,0xFB,
  0xBE,0x4B,0x00,0xFB,0x03,0x00,0x90,0x0B,0x00,0xF4,0xFF,0xFF,0xFF,0x5F,0x00,0xFB,
  0x03,0x20,0xFC,0x5F,0x00,0x30,0x01,0xF0,0x0B,0x00,0x00,0xFB,0x03,0xF7,0xDF,0x04,
  0x00,0x00,0x00,0xF0,0x0B,0x00,0x00,0xFB,0xD7,0xFF,0x19,0x00,0x00,0x00,0x00,0xF0,
  0x0B,0x00,0x00,0xFB,0xFF,0x3B,0x00,0x00,0x00,0x00,0x00,0xF0,0x7D,0xAA,0x00,0xFB,
  0x5D,0x00,0x00,0x00,0x00,0x63,0xB8,0xFE,0xFF,0xDF,0x00,0xFB,0x04,0x00,0x00,0x00,
  0x00,0xFD,0xFF,0xFF,0x6D,0x03,0x00,0xFB,0x03,0x00,0x00,0x70,0x02,0xA8,0x47,0xF1,
  0x0B,0x00,0x00,0xFB,0x03,0x00,0x00,0xD0,0x0E,0x00,0x00,0xF0,0x0B,0x00,0x00,0xFB,
  0x04,0x00,0x00,0xE0,0x0D,0x00,0x00,0xF0,0x0B,0x00,0x00,0xFA,0x06,0x00,0x00,0xF4,
  0x0A,0x00,0x00,0xF0,0x0B,0x00,0x00,0xF7,0xFF,0xFF,0xFF,0xFF,0x05,0x00,0x00,0xF0,
  0x0B,0x00,0x00,0x70,0xCA,0xCC,0xCC,0x6B,0x00,0x00,0x00,0x50,0x04,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x30,0x16,0x00,0x00,0x00,0x00,0x51,0x04,0x00,0x00,
  0x00,0x00,0xF7,0x03,0x00,0x00,0x00,0x20,0xBF,0x00,0x00,0x00,0x00,0x70,0x3F,0x00,
  0x00,0x00,0x00,0xF2,0x0B,0x00,0x00,0x00,0x00,0xF7,0x03,0x00,0x00,0x00,0x20,0xFF,
  0xFF,0xFF,0x9F,0x00,0x70,0x3F,0x00,0x00,0x00,0x00,0xF2,0xCE,0xCC,0xCC,0x07,0x00,
  0xF7,0x03,0x00,0x00,0x00,0x20,0xBF,0x00,0x00,0x00,0xFF,0xFF,0xFF,0xFF,0x0C,0x00,
  0x00,0xF2,0x0B,0x00,0x00,0xF0,0xCD,0xFD,0xCC,0xCE,0x40,0xBB,0xBB,0xEF,0xBB,0xBB,
  0x03,0x7F,0x70,0x3F,0xB0,0x0C,0xF6,0xFF,0xFF,0xFF,0xFF,0x4F,0xF0,0x07,0xF7,0x03,
  0xCB,0x60,0x5F,0x00,0x00,0x00,0xF7,0x04,0x7F,0x70,0x3F,0xB0,0x0C,0xF6,0x05,0x10,
  0x01,0x70,0x4F,0xF0,0x07,0xF7,0x03,0xCB,0x60,0x5F,0x00,0xDE,0x00,0xF7,0x04,0x7F,
  0x70,0x3F,0xB0,0x0C,0xF6,0x05,0xE0,0x0D,0x70,0x4F,0xF0,0x07,0xF7,0x03,0xCB,0x60,
  0x5F,0x00,0xDE,0x00,0xF7,0x04,0x7F,0x70,0x3F,0xB0,0x0C,0xF6,0x05,0xE0,0x0D,0x70,
  0x4F,0xF0,0x07,0xF7,0x03,0xCB,0x60,0x5F,0x00,0xDE,0x00,0xF7,0x04,0x7F,0x70,0x3F,
  0xB0,0x0C,0xF6,0x05,0xF0,0x0C,0x70,0x4F,0xF0,0x07,0xF7,0x03,0xCC,0x60,0x5F,0x20,
  0xBF,0x00,0xF7,0x04,0x7F,0x70,0x4F,0xFF,0x0A,0xF6,0x05,0xF5,0x08,0x70,0x4F,0xE0,
  0x07,0xF7,0x93,0x29,0x50,0x4E,0xC0,0x4F,0x00,0xD6,0x04,0x00,0x70,0x3F,0x00,0x00,
  0x00,0x70,0xBF,0x60,0x00,0x00,0x00,0x00,0xF7,0x03,0x00,0x00,0x60,0xEF,0x72,0xDF,
  0x05,0x00,0x00,0x70,0x3F,0x00,0x00,0xB2,0xEF,0x04,0x60,0xFE,0x1B,0x00,0x00,0xF7,
  0x03,0x40,0xFA,0xCF,0x02,0x00,0x20,0xFB,0x4E,0x00,0x70,0x3F,0x00,0xF5,0x6D,0x00,
  0x00,0x00,0x00,0xF7,0x07,0x00,0x73,0x01,0x00,0x04,0x00,0x00,0x00,0x00,0x00,0x03,
  0x20,0xEB,0x8D,0x01,0xE2,0x6C,0xE7,0x0A,0xD9,0x01,0x50,0x3F,0xAC,0x00,0x10,0x6F,
  0xCA,0x00,0x20,0x4F,0xF5,0x17,0xC2,0x1D,0x70,0xFF,0xDF,0x03,0x00,0x41,0x03,0x00,
  0xFD,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xEF,0xFD,0xBB,0xBB,0xBB,0xBB,
  0xBB,0xBB,0xBB,0xBB,0xBB,0xEF,0xFD,0x00,0x00,0x01,0x00,0x88,0x00,0x20,0x00,0x00,
  0xEF,0xFD,0x00,0x80,0x1D,0x00,0xBE,0x00,0xF3,0x07,0x00,0xEF,0xFD,0x00,0x10,0x9E,
  0x40,0x6F,0x00,0xEA,0x01,0x00,0xEF,0xFD,0x00,0x43,0x79,0xA4,0x6F,0x54,0x9F,0x44,
  0x00,0xEF,0xFD,0x00,0xFA,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x00,0xEF,0xFD,0x00,0x00,
  0x00,0xF8,0x05,0x00,0x00,0x00,0x00,0xEF,0xFD,0x40,0x44,0x54,0xEF,0x44,0x44,0x44,
  0x44,0x04,0xEF,0xFD,0xD0,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x0F,0xEF,0xFD,0x00,
  0x10,0xFB,0x06,0x00,0x40,0xAF,0x00,0x00,0xEF,0xFD,0x00,0xB1,0x9F,0x00,0x00,0x00,
  0xF8,0x09,0x00,0xEF,0xFD,0x50,0xFD,0xFD,0xFF,0xFF,0xFF,0x97,0xCF,0x04,0xEF,0xFD,
  0xF5,0x4D,0xF6,0x47,0x44,0xF5,0x06,0xE6,0x4F,0xEF,0xFD,0x60,0x01,0xF6,0x03,0x00,
  0xF3,0x04,0x10,0x05,0xEF,0xFD,0x00,0x00,0xF6,0x03,0xF8,0xDF,0x11,0x00,0x00,0xEF,
  0xFD,0x00,0x00,0xF6,0x03,0x21,0x02,0x80,0x0C,0x00,0xEF,0xFD,0x00,0x00,0xF5,0x06,
  0x00,0x00,0xC1,0x0B,0x00,0xEF,0xFD,0x00,0x00,0xE1,0xFF,0xFF,0xFF,0xFF,0x06,0x00,
  0xEF,0xFD,0x00,0x00,0x10,0x54,0x55,0x55,0x24,0x00,0x00,0xEF,0xFD,0x99,0x99,0x99,
  0x99,0x99,0x99,0x99,0x99,0x99,0xEF,0xFD,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
  0xFF,0xEF,0xFD,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xEF,0x43,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x34,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0x00,
  0x20,0x00,0x00,0x00,0x00,0x00,0x80,0x6F,0x00,0x00,0x00,0x00,0xE1,0x4D,0x00,0x00,
  0x00,0x00,0x30,0xEF,0x03,0x00,0x00,0x00,0xF7,0x0C,0x00,0x00,0x00,0x00,0x00,0xF7,
  0x0C,0x00,0x00,0x10,0xFE,0x03,0x00,0x00,0x00,0x00,0x00,0xD0,0x5F,0x00,0x00,0xA0,
  0x8F,0x00,0x00,0x00,0x00,0xA2,0xAA,0xCA,0xAE,0xAA,0xAA,0xFA,0xAF,0xAA,0x4A,0x00,
  0x00,0xF2,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x6F,0x00,0x00,0xF2,0x0B,0x00,
  0x00,0xF1,0x0E,0x00,0x00,0x90,0x6F,0x00,0x00,0xF2,0x0B,0x00,0x00,0xF1,0x0E,0x00,
  0x00,0x90,0x6F,0x00,0x00,0xF2,0x0B,0x00,0x00,0xF1,0x0E,0x00,0x00,0x90,0x6F,0x00,
  0x00,0xF2,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x6F,0x00,0x00,0xF2,0x8D,0x88,
  0x88,0xF9,0x8F,0x88,0x88,0xC8,0x6F,0x00,0x00,0xF2,0x0B,0x00,0x00,0xF1,0x0E,0x00,
  0x00,0x90,0x6F,0x00,0x00,0xF2,0x0B,0x00,0x00,0xF1,0x0E,0x00,0x00,0x90,0x6F,0x00,
  0x00,0xF2,0xAE,0xAA,0xAA,0xFA,0xAF,0xAA,0xAA,0xDA,0x6F,0x00,0x00,0xF2,0xFF,0xFF,
  0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x6F,0x00,0x00,0x00,0x00,0x00,0x00,0xF1,0x0E,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xF1,0x0E,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0xF1,0x0E,0x00,0x00,0x00,0x00,0x00,0xF9,0xFF,0xFF,0xFF,
  0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xAF,0xC8,0xCC,0xCC,0xCC,0xCC,0xFD,0xCF,0xCC,
  0xCC,0xCC,0xCC,0x8C,0x00,0x00,0x00,0x00,0x00,0xF1,0x0E,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0xF1,0x0E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0xF1,0x0E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xF1,0x0E,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x71,0x06,0x00,0x00,0x00,0x00,0x00,
};

static const dial_glyph_t star_cjk_glyphs[7] = {
  {0xC0, 1, 10, 25, 26, 1664, &star_cjk_bits[0]},  /* 梅 */
  {0xC1, 2, 10, 24, 26, 1664, &star_cjk_bits[325]},  /* 花 */
  {0xC2, 2, 10, 24, 26, 1664, &star_cjk_bits[637]},  /* 轮 */
  {0xC3, 3, 10, 23, 26, 1664, &star_cjk_bits[949]},  /* 帧 */
  {0xB0, 2, 13, 8, 8, 616, &star_cjk_bits[1248]},  /* ° */
  {0xC4, 3, 12, 22, 24, 1664, &star_cjk_bits[1280]},  /* 圈 */
  {0xC5, 2, 10, 24, 26, 1664, &star_cjk_bits[1544]},  /* 单 */
};


#define CH_MEI   "\xC0"
#define CH_HUA   "\xC1"
#define CH_LUN   "\xC2"
#define CH_ZHEN  "\xC3"
#define CH_CHI   "\xD7"
#define CH_DEG   "\xB0"
#define CH_QUAN  "\xC4"
#define CH_DAN   "\xC5"

static const dial_glyph_t *glyph(uint8_t code)
{
  uint32_t i;
  for (i = 0; i < DIAL_FONT_NGLYPH; i++)
  {
    if (dial_font_glyphs[i].code == code) { return &dial_font_glyphs[i]; }
  }
  for (i = 0; i < 6U; i++)
  {
    if (star_extra_glyphs[i].code == code) { return &star_extra_glyphs[i]; }
  }
  for (i = 0; i < 7U; i++)
  {
    if (star_cjk_glyphs[i].code == code) { return &star_cjk_glyphs[i]; }
  }
  return 0;
}

static void blend_px(uint16_t *fb, int fb_w, int fb_h, int x, int y, int a, uint16_t ink)
{
  uint16_t p, out;
  int pr, pg, pb, ir, ig, ib;
  if ((a <= 0) || (x < 0) || (y < 0) || (x >= fb_w) || (y >= fb_h)) { return; }
  if (a > 15) { a = 15; }
  p = fb[(y * fb_w) + x];
  pr = (((p >> 11) & 31) * 255) / 31;
  pg = (((p >> 5) & 63) * 255) / 63;
  pb = ((p & 31) * 255) / 31;
  ir = (((ink >> 11) & 31) * 255) / 31;
  ig = (((ink >> 5) & 63) * 255) / 63;
  ib = ((ink & 31) * 255) / 31;
  pr = ((pr * (15 - a)) + (ir * a)) / 15;
  pg = ((pg * (15 - a)) + (ig * a)) / 15;
  pb = ((pb * (15 - a)) + (ib * a)) / 15;
  out = (uint16_t)(((pr * 31 / 255) << 11) | ((pg * 63 / 255) << 5) | (pb * 31 / 255));
  fb[(y * fb_w) + x] = out;
}

static int draw_code(uint16_t *fb, int fb_w, int fb_h, int x, int y, uint8_t code, uint16_t ink)
{
  const dial_glyph_t *g = glyph(code);
  int ix, iy;
  if (g == 0) { return 8; }
  for (iy = 0; iy < (int)g->h; iy++)
  {
    for (ix = 0; ix < (int)g->w; ix++)
    {
      uint32_t bit_i = (((uint32_t)iy * (uint32_t)g->w) + (uint32_t)ix);
      uint8_t by = g->bits[bit_i / 2U];
      int a = ((bit_i & 1U) == 0U) ? (int)(by & 0x0FU) : (int)(by >> 4);
      if (a != 0) { blend_px(fb, fb_w, fb_h, x + (int)g->xoff + ix, y + (int)g->yoff + iy, a, ink); }
    }
  }
  return (int)((g->adv64 + 32) / 64);
}

static int draw_str_ink(uint16_t *fb, int fb_w, int fb_h, int x, int y, const char *s, uint16_t ink)
{
  int x0 = x;
  if (s == 0) { return 0; }
  while (*s)
  {
    x += draw_code(fb, fb_w, fb_h, x, y, (uint8_t)*s, ink);
    s++;
  }
  return x - x0;
}

static int measure_str(const char *s)
{
  int x = 0;
  if (s == 0) { return 0; }
  while (*s)
  {
    const dial_glyph_t *g = glyph((uint8_t)*s++);
    x += (g != 0) ? (int)((g->adv64 + 32) / 64) : 8;
  }
  return x;
}

static char *put_u(char *p, uint32_t v, int digits)
{
  int i;
  for (i = digits - 1; i >= 0; i--)
  {
    p[i] = (char)('0' + (char)(v % 10U));
    v /= 10U;
  }
  return p + digits;
}

static char *put_uv(char *p, uint32_t v)
{
  char rev[12];
  int k = 0;
  if (v == 0U) { *p++ = '0'; return p; }
  while (v > 0U) { rev[k++] = (char)('0' + (char)(v % 10U)); v /= 10U; }
  while (k > 0) { *p++ = rev[--k]; }
  return p;
}

static char *put_frac(char *p, uint32_t v, uint32_t scale, int frac)
{
  p = put_uv(p, v / scale);
  *p++ = '.';
  return put_u(p, v % scale, frac);
}

static char *put_str(char *p, const char *s)
{
  while (*s) { *p++ = *s++; }
  return p;
}

/* 画一行：最后一个空格之后的部分用蓝字。 */
static void draw_line_split(uint16_t *fb, int fb_w, int fb_h, int x, int y, char *line)
{
  char *sp = 0;
  char *q = line;
  while (*q != 0) { if (*q == ' ') { sp = q; } q++; }
  if (sp == 0)
  {
    (void)draw_str_ink(fb, fb_w, fb_h, x, y, line, TXT_INK);
    return;
  }
  *sp = 0;
  x += draw_str_ink(fb, fb_w, fb_h, x, y, line, TXT_INK);
  x += draw_code(fb, fb_w, fb_h, x, y, (uint8_t)' ', TXT_INK);
  *sp = ' ';
  (void)draw_str_ink(fb, fb_w, fb_h, x, y, sp + 1, TXT_VAL);
}

void StarTrack_Paint(uint16_t *fb, uint16_t fb_w, uint16_t fb_h, int16_t ox, int16_t oy,
                     uint32_t stamp_us, const dial_time_t *t, uint8_t phase)
{
  char l1[48];
  char l2[48];
  char l3[48];
  char l4[48];
  char rows[STAR_MEAS_HIST][56];
  int W = (int)fb_w, H = (int)fb_h;
  const int hx = 12, hy = 8, gap = 28, pad = 8;
  int tw, k, nk, x1, y1, xv;
  char *p;

  if ((fb == 0) || (fb_w < 16U) || (fb_h < 16U)) { return; }
  if ((stamp_us != s_last_lcd_stamp) && (s_last_lcd_stamp != 0U))
  {
    g_star_frame_dt_us = stamp_us - s_last_lcd_stamp;
  }
  s_last_lcd_stamp = stamp_us;

  /* 实时画面上的标记：黄=齿顶圆，绿=采样圆环，白=跟着轮转的缺口相位 */
  if (g_star.found != 0U)
  {
    int cx = (int)ox + (int)g_star.cx;
    int cy = (int)oy + (int)g_star.cy;
    draw_circle(fb, W, H, cx, cy, g_star.r_out, LIVE_RIM, 2, 2, 0, 0, W, H);
    if ((g_star.armed != 0U) && (phase >= 2U))
    {
      float ang;
      draw_circle(fb, W, H, cx, cy, g_star.ann_r0, LIVE_ANN, 1, 4, 0, 0, W, H);
      draw_circle(fb, W, H, cx, cy, g_star.ann_r1, LIVE_ANN, 1, 4, 0, 0, W, H);
      ang = (s_phase0 + (float)(g_star_accum * (double)ST_TWO_PI)) / (float)g_star.n_teeth;
      draw_ray(fb, W, H, cx, cy, ang, 0, g_star.r_out + 8, LIVE_MARK, 3, 0, 0, W, H);
    }
    plot(fb, W, H, cx, cy, LIVE_RIM, 5, 0, 0, W, H);
  }

  p = l1;
  if (t != 0)
  {
    p = put_u(p, (uint32_t)t->year, 4); *p++ = '-';
    p = put_u(p, (uint32_t)t->mon, 2); *p++ = '-';
    p = put_u(p, (uint32_t)t->day, 2); *p++ = ' ';
    p = put_u(p, (uint32_t)t->hour, 2); *p++ = ':';
    p = put_u(p, (uint32_t)t->min, 2); *p++ = ':';
    p = put_u(p, (uint32_t)t->sec, 2);
    if (g_star_frame_dt_us != 0U)
    {
      *p++ = ' ';
      p = put_uv(p, g_star_frame_dt_us / 1000U);
      *p++ = ' '; *p++ = 'm'; *p++ = 's';
    }
  }
  else
  {
    *p++ = '?';
  }
  *p = 0;

  p = l2;
  p = put_str(p, CH_MEI CH_HUA CH_LUN " ");
  if (g_star.found != 0U)
  {
    p = put_uv(p, (uint32_t)g_star.n_teeth);
    p = put_str(p, CH_CHI);
    if ((phase >= 2U) && (g_star_fps_e1 > 0))
    {
      *p++ = ' ';
      p = put_frac(p, (uint32_t)g_star_fps_e1, 10U, 1);
      p = put_str(p, CH_ZHEN "/s");
    }
  }
  else
  {
    p = put_str(p, "---");
  }
  *p = 0;

  p = l3;
  if ((phase >= 2U) && (s_have_prev != 0U))
  {
    if (g_star_meas_n >= 3U)
    {
      p = put_frac(p, (uint32_t)g_star_rep_e4, 10000U, 4);
      *p++ = '%';
    }
    else
    {
      p = put_str(p, "---");
    }
    *p++ = ' ';
    p = put_frac(p, (uint32_t)(g_star_ang_mdeg / 10), 100U, 2);
    p = put_str(p, CH_DEG " ");
    p = put_frac(p, (uint32_t)g_star_dps_e3, 1000U, 3);
    p = put_str(p, CH_DEG "/s");
  }
  else
  {
    p = put_str(p, "---");
  }
  *p = 0;

  /* 第 4 行：单圈用时、本窗圈数进度、本圈已转角度 */
  p = l4;
  p = put_str(p, CH_DAN CH_QUAN " ");
  if (g_star_lap_us != 0U)
  {
    p = put_frac(p, (g_star_lap_us + 500U) / 1000U, 1000U, 3);
    *p++ = 's';
  }
  else
  {
    p = put_str(p, "---");
  }
  *p++ = ' ';
  p = put_uv(p, (uint32_t)g_star_mw_laps);
  *p++ = '/';
  if (g_star_mw_target == 0U) { p = put_str(p, ">30s"); }
  else { p = put_uv(p, (uint32_t)g_star_mw_target); p = put_str(p, CH_QUAN); }
  *p++ = ' ';
  p = put_frac(p, (uint32_t)(g_star_lap_deg * 10.0), 10U, 1);
  p = put_str(p, CH_DEG);
  *p = 0;

  nk = (int)g_star_meas_n;
  tw = measure_str(l1);
  xv = measure_str(l2); if (xv > tw) { tw = xv; }
  xv = measure_str(l3); if (xv > tw) { tw = xv; }
  xv = measure_str(l4); if (xv > tw) { tw = xv; }
  for (k = 0; k < nk; k++)
  {
    int idx = (int)g_star_meas_i - 1 - k;
    if (idx < 0) { idx += (int)STAR_MEAS_HIST; }
    p = rows[k];
    *p++ = '[';
    p = put_u(p, (uint32_t)g_star_meas_seq[idx], 3);
    *p++ = ']'; *p++ = ' ';
    p = put_frac(p, (g_star_meas_dt_us[idx] + 5U) / 10U, 100000U, 5);
    *p++ = 's'; *p++ = ' ';
    p = put_frac(p, (uint32_t)iabs32(g_star_meas_ang_mdeg[idx]), 1000U, 3);
    p = put_str(p, CH_DEG " ");
    p = put_frac(p, (uint32_t)g_star_meas_dps_e3[idx], 1000U, 3);
    p = put_str(p, CH_DEG "/s");
    *p = 0;
    xv = measure_str(rows[k]);
    if (xv > tw) { tw = xv; }
  }
  x1 = hx + tw + pad;
  y1 = hy + ((4 + nk) * gap) + pad + 12;
  if ((ox > 0) && (x1 > (int)ox) && (phase >= 1U)) { x1 = (int)ox; }
  if (x1 >= W) { x1 = W - 1; }
  if (y1 >= H) { y1 = H - 1; }
  fill_rect(fb, W, H, hx - pad, hy - pad, x1, y1, 0xFFFFU);
  s_hud_x1 = (uint16_t)(x1 + 4);
  s_hud_y1 = (uint16_t)(y1 + 4);
  (void)draw_str_ink(fb, W, H, hx, hy, l1, TXT_INK);
  (void)draw_str_ink(fb, W, H, hx, hy + gap, l2, TXT_INK);
  draw_line_split(fb, W, H, hx, hy + (2 * gap), l3);
  (void)draw_str_ink(fb, W, H, hx, hy + (3 * gap), l4, TXT_INK);
  for (k = 0; k < nk; k++)
  {
    draw_line_split(fb, W, H, hx, hy + ((4 + k) * gap), rows[k]);
  }
}
